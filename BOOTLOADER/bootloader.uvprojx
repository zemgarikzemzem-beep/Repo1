# Keil uVision project bootloader.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\lib;.\lib\inc;.\lib\src
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./: main.c
    ./lib/src/: chipcon.c spi.c disp.c data.c flash.c rcc.c gpio.c tim.c fonts.c eeprom.c
  group startup
    ./lib/: startup_stm32f030x8.s system_stm32f0xx.c
