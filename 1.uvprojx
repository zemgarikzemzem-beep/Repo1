# Keil uVision project 1.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030CCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\lib;.\lib\inc
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x200000c0 size 0x8000
  group user
    ./: main.c
    ./lib/src/: adc.c alerts.c bootloader.c chipcon.c CRC.c data.c disp.c exti.c fft.c flash.c fonts.c gpio.c iwdg.c i2c.c pwr.c rcc.c rtc.c spi.c tft-menu.c tim.c SysTick.c
  group startup
    ./lib/: system_stm32f0xx.c startup_stm32f030x8.s
